File: Proyectos_KiCad/AguaV1.0/Power.kicad_sch (KiCad schematic)
At the start: 6 parts, among them J1 VIN, U3 AMS1117-3.3

Commit message: Omarchy-RIP
Parts:
- U2: value ~ -> (none)
